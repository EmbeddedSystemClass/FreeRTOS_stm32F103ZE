# Keil uVision project RTOSDemo.uvprojx, settings and files
target uart_cli (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo
  AfterMake: cmd.exe /c $J\..\bin\fromelf.exe --bin -o "bin/" "#L" && $J\..\bin\fromelf.exe -acd --interleave=source -o "bin\@L.disasm" "#L"
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;..\Common\include;..\Source\include;.\STM32F10xFWLib\inc;.\serial;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ./: STM32F10x.s
    ../Common/drivers/ST/STM32F10xFWLib/src/: lcd.c cortexm3_macro_rvds.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c
  group Demo Files
    ./ParTest/: ParTest.c
    ./serial/: serial.c
    ./: timertest.c main.c spi_flash.c
    ../Common/Minimal/: semtest.c BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c
  group FreeRTOS files
    ../Source/: tasks.c list.c queue.c
    ../Source/portable/RVDS/ARM_CM3/: port.c
    ../Source/portable/MemMang/: heap_2.c
  group Cli
    ./serial/: CLI-commands.c File-Related-CLI-commands.c Run-time-stats-utils.c Sample-CLI-commands.c UARTCommandConsole.c trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c FreeRTOS_CLI.c
